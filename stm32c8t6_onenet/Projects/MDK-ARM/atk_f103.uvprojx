# Keil uVision project atk_f103.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE USE_STDPERIPH_DRIVER
  c include: ..\..\Library\inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\HC_SR505;..\..\Drivers\BSP\HX711;..\..\Drivers\BSP\KEY;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\RELAY;..\..\Drivers\BSP\ESP8266;..\..\Drivers\BSP\ONENET;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c
  group Library
    ../../Library/src/: core_cm3.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_iwdg.c assert.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/tick/: tick.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/HC_SR505/: hc_sr505.c
    ../../Drivers/BSP/HX711/: hx711.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/RELAY/: relay.c
    ../../Drivers/BSP/WDG/: wdg.c
    ../../Drivers/BSP/ESP8266/: esp8266.c
    ../../Drivers/BSP/ONENET/: mqttkit.c base64.c hmac_sha1.c onenet_protocol.c onenet.c
  group readme
    ../../: 引脚分配表.txt README.md
