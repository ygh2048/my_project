# Keil uVision project atk_f103.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE USE_STDPERIPH_DRIVER
  c include: ..\CORE\Include;..\CORE\Device\ST\STM32F1xx\Source;..\CORE\Device\ST\STM32F1xx\Source\Templates;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\tick;..\HARDWARE\ADC;..\HARDWARE\HC_SR505;..\HARDWARE\HX711;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\RELAY;..\HARDWARE\WDG;..\HARDWARE\ESP8266;..\HARDWARE\ONENET;.;.\APP
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../CORE/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../USER/: main.c
    ../USER/APP/: app_runtime.c app_system.c app_display.c app_input.c
  group Library
    ../STM32F10x_FWLib/src/: core_cm3.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_iwdg.c assert.c
  group Drivers/SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/tick/: tick.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/HC_SR505/: hc_sr505.c
    ../HARDWARE/HX711/: hx711.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/ONENET/: mqttkit.c base64.c hmac_sha1.c onenet_protocol.c onenet.c
  group readme
    ../: README.md 引脚分配表.txt
