# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\IIC;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\MALLOC;..\FWLIB\CMSIS\Include;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\Demo;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\BEEP;..\HARDWARE\ADC;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c task.c task.h mine.c mine.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ott2001a.c touch.c gt9147.c ft5206.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group DSP_Lib
    ../FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../FWLIB/CMSIS/Include/: arm_math.h
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM4_OS_Keil.lib
  group EMWIN_Demo
    ../EMWIN/Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
